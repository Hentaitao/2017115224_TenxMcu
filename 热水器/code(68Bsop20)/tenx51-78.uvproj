# Keil uVision project tenx51-78.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5268B tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000)
  output: tenx51-78 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_TENX52.A51 display.c init.c main.c display.h includeAll.h init.h main.h REGtenxTM52F5278B.h typeAlias.h REGtenxTM52F5268B.h keys.c buzz.c
